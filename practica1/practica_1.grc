options:
  parameters:
    author: yo
    copyright: UIS
    description: Generar señales desde el radio definido por software.
    generate_options: qt_gui
    id: practica_1
    output_language: python
    title: conexion USRP
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: ganancia receptor
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '0'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fRX
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora receptor
    start: 50e6
    step: 1e5
    stop: 2200e6
    value: 50e6
  states: {}
- name: fTX
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora transmisor
    start: 50e6
    step: 1e6
    stop: 2200e6
    value: 50e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: k1
  id: variable_qtgui_range
  parameters:
    label: habilita real
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: k2
  id: variable_qtgui_range
  parameters:
    label: habilita imaginaria
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/2
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Parte real de la g(t).
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    comment: Parte imaginaria de la g(t).
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: k2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: k1
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: TX
    label2: RX
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: real TX
    label2: imag TX
    label3: real RX
    label4: imag RX
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fTX
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fRX
    comment: configuracion del transmisor modo fuente.
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
