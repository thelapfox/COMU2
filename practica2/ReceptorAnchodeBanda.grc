options:
  parameters:
    author: Nicolas_Murillo_William_moncada
    copyright: UIS
    description: ReceptorAnchodeBanda
    generate_options: qt_gui
    id: ReceptorAnchodeBanda
    output_language: python
    title: lab1_Comu2_parte2
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia_RX
    start: '0'
    step: '0.500'
    stop: '31.5'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia_Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12500000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
